# Repository A622266/NZIF_Radio (continued)

## KiCad design nzif/nzif.kicad_pcb (continued)

Schematic: rx_driver_amps.kicad_sch, Differential Driver Amps (Rx)

Parts:
C301, C302, C305, C306, C311, C312, C323, C324, C327, C330, C333, C336: 10u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder; Digikey Part # 587-3258-1-ND
C303, C304, C307, C308, C309, C310, C313, C314, C315, C316, C317, C318, C325, C326, C328, C329, C331, C332, C334, C335, C337, C338, C339, C342: 0.1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder; Digikey Part # 490-GCM31C5C1H104FA16LCT-ND
C319, C320, C321, C322, C340, C341, C343, C344: 180p; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder; Digikey Part # 490-GCM31C5C1H104FA16LCT-ND; not fitted
R301, R303, R315, R319: 3.4k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder; Digikey Part # 311-3.40KHRCT-ND
R302, R304, R312, R314, R316, R320, R326, R328: 9.53k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder; Digikey Part # 311-9.53KHRCT-ND
R305, R306, R311, R313, R321, R324, R325, R327: 10k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder; Digikey Part # 311-10.0KHRCT-ND
R307, R308, R309, R310, R317, R318, R322, R323: 1k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder; Digikey Part # 311-1.00KHRCT-ND
U301, U302, U307, U308: LT5400BCMS8E-8-TRPBF; MSOP-8_MS_LIT; Digikey Part # LT5400BCMS8E-1#PBF-ND
U303, U305, U311, U312: ADA4945-1; LFCSP16_ADA4945-1ACPZ-R2_ADI
U304, U306, U309, U310: ADG884xCP; LFCSP-WD-10-1EP_3x3mm_P0.5mm_EP1.64x2.38mm; Digikey Part # 505-ADG884BRMZ-ND

Connections:
+3.3V_DSP_UC: C301.1, C302.1, C303.1, C304.1, C323.1, C324.1, C325.1, C326.1, U304.1 (VDD), U306.1 (VDD), U309.1 (VDD), U310.1 (VDD); also elsewhere on the board
+6.5V_RX_OPAMPS: C305.1, C306.1, C307.1, C308.1, C309.1, C310.1, C327.1, C328.1, C329.1, C330.1, C331.1, C332.1, R301.1, R303.1, R305.2, R306.2, R315.1, R319.1, R321.2, R324.2, U303.5 (MODE), U303.6 (+VS), U303.7 (+VS), U305.5 (MODE), U305.6 (+VS), U305.7 (+VS), U311.5 (MODE), U311.6 (+VS), U311.7 (+VS), U312.5 (MODE), U312.6 (+VS), U312.7 (+VS); also elsewhere on the board
-3.5V_RX_OPAMPS: C311.1, C312.1, C314.1, C316.1, C317.1, C318.1, C333.1, C335.1, C336.1, C337.1, C339.1, C342.1, R311.1, R313.1, R325.1, R327.1, U303.14 (-VS), U303.15 (-VS), U303.17 (EPAD), U305.14 (-VS), U305.15 (-VS), U305.17 (EPAD), U311.14 (-VS), U311.15 (-VS), U311.17 (EPAD), U312.14 (-VS), U312.15 (-VS), U312.17 (EPAD); also elsewhere on the board
/ADCs/ADC_VREF: C313.1, C315.1, C334.1, C338.1, U303.9 (VOCM), U305.9 (VOCM), U311.9 (VOCM), U312.9 (VOCM); also elsewhere on the board
/ADCs/AIN1N: U303.10 (+OUT); also elsewhere on the board
/ADCs/AIN1P: U303.11 (-OUT); also elsewhere on the board
/ADCs/AIN2N: U305.10 (+OUT); also elsewhere on the board
/ADCs/AIN2P: U305.11 (-OUT); also elsewhere on the board
/ADCs/AIN3N: U312.10 (+OUT); also elsewhere on the board
/ADCs/AIN3P: U312.11 (-OUT); also elsewhere on the board
/ADCs/AIN4N: U311.10 (+OUT); also elsewhere on the board
/ADCs/AIN4P: U311.11 (-OUT); also elsewhere on the board
/FDA_GAIN_SEL: U304.4 (IN1), U304.8 (IN2), U306.4 (IN1), U306.8 (IN2), U309.4 (IN1), U309.8 (IN2), U310.4 (IN1), U310.8 (IN2); also elsewhere on the board
/RX_Driver_Amps/+VCLAMP: R301.2, R302.1, R303.2, R304.1, R315.2, R316.1, R319.2, R320.1, U303.8 (+VCLAMP), U305.8 (+VCLAMP), U311.8 (+VCLAMP), U312.8 (+VCLAMP)
/RX_Driver_Amps/-VCLAMP: R311.2, R312.1, R313.2, R314.1, R325.2, R326.1, R327.2, R328.1, U303.13 (-VCLAMP), U305.13 (-VCLAMP), U311.13 (-VCLAMP), U312.13 (-VCLAMP)
/RX_Driver_Amps/LT5400_p1: U301.1 (R1), U302.1 (R1), U304.10 (S2A), U306.10 (S2A), U307.1 (R1), U308.1 (R1), U309.10 (S2A), U310.10 (S2A)
/RX_Driver_Amps/LT5400_p4: U301.4 (R4), U302.4 (R4), U304.5 (S1B), U306.5 (S1B), U307.4 (R4), U308.4 (R4), U309.5 (S1B), U310.5 (S1B)
/RX_Driver_Amps/P0_FB+: C320.1, U303.4 (+FB), U304.9 (D2)
/RX_Driver_Amps/P0_FB-: C319.1, U303.1 (-FB), U304.3 (D1)
/RX_Driver_Amps/P0_IN+: C319.2, R307.1, U301.3 (R3), U301.5 (R4), U301.6 (R3), U303.2 (+IN); also elsewhere on the board
/RX_Driver_Amps/P0_IN-: C320.2, R308.1, R318.1, U301.2 (R2), U301.7 (R2), U301.8 (R1), U303.3 (-IN); also elsewhere on the board
/RX_Driver_Amps/P1_FB+: C322.1, U305.4 (+FB), U306.9 (D2)
/RX_Driver_Amps/P1_FB-: C321.1, U305.1 (-FB), U306.3 (D1)
/RX_Driver_Amps/P1_IN+: C321.2, R309.1, U302.5 (R4), U302.6 (R3), U305.2 (+IN)
/RX_Driver_Amps/P1_IN-: C322.2, R310.1, U302.7 (R2), U302.8 (R1), U305.3 (-IN)
/RX_Driver_Amps/P2_FB+: C344.1, U310.9 (D2), U312.4 (+FB)
/RX_Driver_Amps/P2_FB-: C343.1, U310.3 (D1), U312.1 (-FB)
/RX_Driver_Amps/P2_IN+: C343.2, R322.1, U308.5 (R4), U308.6 (R3), U312.2 (+IN)
/RX_Driver_Amps/P2_IN-: C344.2, R323.1, U308.7 (R2), U308.8 (R1), U312.3 (-IN)
/RX_Driver_Amps/P3_FB+: C341.1, U309.9 (D2), U311.4 (+FB)
/RX_Driver_Amps/P3_FB-: C340.1, U309.3 (D1), U311.1 (-FB)
/RX_Driver_Amps/P3_IN+: C340.2, R317.1, U307.5 (R4), U307.6 (R3), U311.2 (+IN)
/RX_Driver_Amps/P3_IN-: C341.2, U307.7 (R2), U307.8 (R1), U311.3 (-IN)
/RX_Driver_Amps/P45_IN+: U302.3 (R3); also elsewhere on the board
/RX_Driver_Amps/P45_IN-: U302.2 (R2); also elsewhere on the board
/RX_Driver_Amps/P90_IN+: U308.3 (R3); also elsewhere on the board
/RX_Driver_Amps/P90_IN-: U308.2 (R2); also elsewhere on the board
/RX_Driver_Amps/P135_IN+: U307.3 (R3); also elsewhere on the board
/RX_Driver_Amps/P135_IN-: U307.2 (R2); also elsewhere on the board
unnamed: R305.1, U303.12 (~DISABLE)
unnamed: R307.2, U304.2 (S1A)
unnamed: R308.2, U304.7 (S2B)
unnamed: R306.1, U305.12 (~DISABLE)
unnamed: R309.2, U306.2 (S1A)
unnamed: R310.2, U306.7 (S2B)
unnamed: R317.2, U309.2 (S1A)
unnamed: R318.2, U309.7 (S2B)
unnamed: R322.2, U310.2 (S1A)
unnamed: R323.2, U310.7 (S2B)
unnamed: R321.1, U311.12 (~DISABLE)
unnamed: R324.1, U312.12 (~DISABLE)

Notes on the sheet:
Set to -1.7V
+VCLAMP set to 4.79V
Set to 4.79V
-VCLAMP set to -1.7V
Feedback resistors LP filter with Rin

Schematic: dsp.kicad_sch, Digital Audio Processor ADAU1467

Parts:
C501, C502, C518, C519: 10u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C503, C504, C505, C506, C507, C508, C509, C510, C511, C522, C523: 10n; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C512, C514, C515, C516, C517, C520, C521, C524, C526, C527, C528, C529: 0.1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C513, C525: .1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C530: 150p; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C531: 5.6n; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
D501: LED; LED_1206_3216Metric_ReverseMount_Hole1.8x2.4mm
Q501: STD2805T4; DPAKTO-252_TYPEA_STM
R501, R502, R503: 10k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R504: 100k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R505, R506: 1k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R507: 4.32k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R508, R509, R510, R511, R512, R513, R514, R515, R516, R517, R518, R519, R520, R521, R522, R523: 33; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R1215: 49.9; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
SW501: SW_SPST; SW_DIP_SPSTx01_Slide_6.7x4.1mm_W6.73mm_P2.54mm_LowProfile_J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
SW502: SW_Push; SW_PUSH_6mm
TP501: VDrive; PinHeader_1x01_P1.27mm_Vertical
TP502: IOVDD; PinHeader_1x01_P1.27mm_Vertical
TP503: DVDD; PinHeader_1x01_P1.27mm_Vertical
U501: ADAU1467WBCPZ300; CP_88_10_ADI
U502: 25AA1024-I/MF; DIP-8_W7.62mm_Socket
U503: ADM811TARTZ-REEL7; RA_4_ADI

Connections:
+3.3V_DSP_UC: C501.2, C503.2, C505.2, C507.2, C509.2, C511.2, C513.1, C514.2, C516.2, C518.2, C519.2, C520.2, C522.2, C523.2, C524.2, C525.2, C526.2, C527.2, C528.2, C529.2, C530.2, C531.1, Q501.3 (Emitter), R502.1, R503.1, R506.2, SW501.2 (B), TP502.1 (1_1), U501.2 (IOVDD), U501.9 (AVDD), U501.19 (PVDD), U501.22 (IOVDD), U501.37 (IOVDD), U501.46 (IOVDD), U501.68 (IOVDD), U502.7 (*HOLD), U502.8 (VCC), U503.4 (VCC); also elsewhere on the board
/ADCs/BCLK_OUT0: R514.1; also elsewhere on the board
/ADCs/LRCLK_OUT0: R513.1; also elsewhere on the board
/ADCs/SDATAOUT1: R508.2; also elsewhere on the board
/Audio_Subsystem/ADC_SDATA: R509.2; also elsewhere on the board
/Audio_Subsystem/BCLK: R520.1; also elsewhere on the board
/Audio_Subsystem/DAC_SDATA: R518.1; also elsewhere on the board
/Audio_Subsystem/LRCLK: R519.1; also elsewhere on the board
/DACs/DAC_BCLK: R517.1; also elsewhere on the board
/DACs/DAC_LRCLK: R516.1; also elsewhere on the board
/DACs/TDM1_SDIN_DAC: R515.1; also elsewhere on the board
/DSP/CW_TONE: U501.10 (AUXADC0); also elsewhere on the board
/DSP/DSP_AUX4: U501.14 (AUXADC4); also elsewhere on the board
/DSP/DSP_AUX5: U501.15 (AUXADC5); also elsewhere on the board
/DSP/DSP_AUX6: U501.16 (AUXADC6); also elsewhere on the board
/DSP/DSP_AUX7: U501.17 (AUXADC7); also elsewhere on the board
/DSP/DVDD: C502.2, C504.2, C506.2, C508.2, C510.2, C512.2, C515.2, C517.2, C521.2, Q501.2 (Collector), TP503.1 (1_1), U501.24 (DVDD), U501.43 (DVDD), U501.65 (DVDD), U501.87 (DVDD)
/DSP/MISO_M: U501.35 (SDA_M/MISO_M/MP3), U502.2 (SO)
/DSP/MOSI_M: U501.33 (MOSI_M/MP1), U502.5 (SI)
/DSP/PLL_FILT: C530.1, R507.2, U501.20 (PLLFILT)
/DSP/SCLK_M: U501.34 (SCL_M/SCLK_M/MP2), U502.6 (SCK)
/DSP/SELFBOOT: D501.1 (K), R501.1, U501.42 (SELFBOOT)
/DSP/SS_M: R502.2, U501.32 (SS_M/MP0), U502.1 (*CS)
/DSP/VAD_ATT: U501.11 (AUXADC1); also elsewhere on the board
/DSP/VAD_LPF: U501.13 (AUXADC3); also elsewhere on the board
/DSP/VAD_REL: U501.12 (AUXADC2); also elsewhere on the board
/DSP/VDrive: Q501.1 (Base), R506.1, TP501.1 (1_1), U501.3 (VDRIVE)
/DSP/~RESET: R504.1, U501.28 (~RESET), U503.2 (RESET*)
/DSP_CLK: R1215.1; also elsewhere on the board
/DSP_MP06: U501.53 (MP6); also elsewhere on the board
/DSP_MP07: U501.54 (MP7); also elsewhere on the board
/DSP_MP10: U501.74 (LRCLK_IN0/MP10); also elsewhere on the board
/DSP_MP11: U501.77 (LRCLK_IN1/MP11); also elsewhere on the board
/DSP_MP12: U501.82 (LRCLK_IN2/MP12); also elsewhere on the board
/DSP_MP14: U501.6 (MP14); also elsewhere on the board
/DSP_MP15: U501.7 (MP15); also elsewhere on the board
/DSP_MP16: U501.72 (SDATAIO0/MP16); also elsewhere on the board
/DSP_MP17: U501.71 (SDATAIO1/MP17); also elsewhere on the board
/DSP_MP18: U501.70 (SDATAIO2/MP18); also elsewhere on the board
/DSP_MP19: U501.69 (SDATAIO3/MP19); also elsewhere on the board
/DSP_MP20: U501.64 (SDATAIO4/MP20); also elsewhere on the board
/DSP_MP21: U501.63 (SDATAIO5/MP21); also elsewhere on the board
/DSP_MP22: U501.62 (SDATAIO6/MP22); also elsewhere on the board
/DSP_MP23: U501.61 (SDATAIO7/MP23); also elsewhere on the board
/DSP_MP24: U501.30 (SCL2_M/MP24); also elsewhere on the board
/DSP_MP25: U501.31 (SDA2_M/MP25); also elsewhere on the board
/SCL0: U501.38 (MISO/SDA); also elsewhere on the board
/SDA0: U501.39 (SCLK/SCL); also elsewhere on the board
/TDM3_BCLK_OUT_HEAD: R523.1; also elsewhere on the board
/TDM3_LRCLK_IN_HEAD: R511.2; also elsewhere on the board
/TDM3_LRCLK_OUT_HEAD: R522.1; also elsewhere on the board
/TDM3_SDATA_IN_HEAD: R510.2; also elsewhere on the board
/TDM3_SDATA_OUT_HEAD: R521.1; also elsewhere on the board
/TDM3_SDOUT_IN_HEAD: R512.2; also elsewhere on the board
/USB_~RESET: R505.2
unnamed: C531.2, R507.1
unnamed: D501.2 (A), SW501.1 (A)
unnamed: R512.1, U501.84 (BCLK_IN3)
unnamed: R514.2, U501.48 (BCLK_OUT0)
unnamed: R517.2, U501.51 (BCLK_OUT1)
unnamed: R520.2, U501.56 (BCLK_OUT2)
unnamed: R522.2, U501.59 (BCLK_OUT3)
unnamed: R511.1, U501.85 (LRCLK_IN3/MP13)
unnamed: R513.2, U501.47 (LRCLK_OUT0/MP4)
unnamed: R516.2, U501.50 (LRCLK_OUT1/MP5)
unnamed: R519.2, U501.55 (LRCLK_OUT2/MP8)
unnamed: R523.2, U501.58 (LRCLK_OUT3/MP9)
unnamed: R508.1, U501.75 (SDATA_IN0)
unnamed: R509.1, U501.83 (SDATA_IN2)
unnamed: R510.1, U501.86 (SDATA_IN3)
unnamed: R515.2, U501.52 (SDATA_OUT1)
unnamed: R518.2, U501.57 (SDATA_OUT2)
unnamed: R521.2, U501.60 (SDATA_OUT3)
unnamed: R1215.2, U501.25 (XTALIN/MCLK)
unnamed: R503.2, U502.3 (*WP)
unnamed: R505.1, SW502.1, U503.3 (MR*)

Notes on the sheet:
PLL Loop Filter
TDM Port 1 DAC
Aux pins to header on top sheet
DVDD Regulator Circuit
TDM port 3 goes to header on top sheet
TDM Port 2 Audio Subsystem
Reset Circuit
ADAU 1467 Eval Board
ADAU1467
TDM Port 3 Header
All MP/GIPO go to header on top sheet
Selfboot Circuit
TDM Port 0 ADC
Eval board used FSM6JSMA for the switch. SMD. maybe switch to that. Also do we need USB_RESET (diode)> Did not include SDP Reset

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
Board: 2 copper layers, 621 parts (0 on the bottom side), 438 nets, no tracks yet.

Other parts of the board:
AE1201, AE1202: Antenna; SMA_Amphenol_901-143_Horizontal
C101: 47u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C103: 0.1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
D1201, D1202, D1203, D1204, D1205, D1206: LED; LED_1206_3216Metric_ReverseMount_Hole1.8x2.4mm
J1204, J1205, J1206: AUX; PinHeader_1x08_P1.27mm_Vertical
J1207: GPIOS; PinHeader_2x12_P1.27mm_Vertical
J1208: SKR; PinHeader_1x02_P1.27mm_Vertical
J1209: TRRS; PinHeader_1x04_P1.27mm_Vertical
J1210, J1211: TS; PinHeader_1x02_P1.27mm_Vertical
J1212: TDM3_IN; PinHeader_1x05_P1.27mm_Vertical
J1213: TDM3_OUT; PinHeader_1x05_P1.27mm_Vertical
J1214: DAC MONITOR; PinHeader_2x04_P1.27mm_Vertical
J1215: I2C; PinHeader_2x05_P1.27mm_Vertical
J1216: STATUS; PinHeader_2x02_P1.27mm_Vertical
J1217: PWR_SW; PinHeader_2x05_P1.27mm_Vertical
J1218: TEST_POINTS; PinHeader_1x14_P1.27mm_Vertical
J1219: Front Panel; PinHeader_2x20_P1.27mm_Vertical
J1220: UART; PinHeader_2x05_P1.27mm_Vertical
J1221: PLL1_OUT; PinHeader_1x01_P1.27mm_Vertical
L1101: 2.7u Wurth WE-TDC 8018 74489430027; TerminalBlock_MaiXu_MX126-5.0-02P_1x02_P5.00mm
R105, R106: 33; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R107, R1207, R1208, R1209, R1210, R1211, R1228: 1k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R1217, R1218, R1221, R1222: 4.7k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder

Their connections:
+3.3V_DSP_UC: J1205.1, J1205.2, J1205.3, J1205.4, J1205.5, J1205.6, J1205.7, J1205.8, J1212.1, J1213.1, J1215.1, R107.1, R1217.1, R1218.1, R1221.1, R1222.1; also elsewhere on the board
/6_-_16V: L1101.1; also elsewhere on the board
/+4V: J1217.5; also elsewhere on the board
/+6V: J1217.3; also elsewhere on the board
/+8V: J1217.1; also elsewhere on the board
/-5V: J1217.7; also elsewhere on the board
/ADC0_FWD_PWR: J1218.12; also elsewhere on the board
/ADC1_REV_PWR: J1218.13; also elsewhere on the board
/ADC2_RSSI: J1218.14; also elsewhere on the board
/AMP_SHUTDOWN: J1219.39; also elsewhere on the board
/ANTI_NOISE: J1219.35; also elsewhere on the board
/Audio_Subsystem/Headphone_L: J1209.1; also elsewhere on the board
/Audio_Subsystem/Headphone_R: J1209.2; also elsewhere on the board
/Audio_Subsystem/Line_Input: J1211.1; also elsewhere on the board
/Audio_Subsystem/MIC_IN: J1209.3; also elsewhere on the board
/Audio_Subsystem/MIC_IN_EXT: J1210.1; also elsewhere on the board
/Audio_Subsystem/Speaker+: J1208.1; also elsewhere on the board
/Audio_Subsystem/Speaker-: J1208.2; also elsewhere on the board
/BAND_SELECT: J1219.13; also elsewhere on the board
/CLK_REF_SEL: J1218.2; also elsewhere on the board
/CLK_REF_TEST: J1218.3; also elsewhere on the board
/CLK_RESET_b: J1218.5; also elsewhere on the board
/CLK_SYNC_b: J1218.4; also elsewhere on the board
/COARSE_TUNE: J1219.17; also elsewhere on the board
/CW_BREAK_IN: J1219.27; also elsewhere on the board
/CW_KEY: J1219.25; also elsewhere on the board
/Clock_Tree/PLL1_OUT: J1221.1 (Pin_1_1); also elsewhere on the board
/Clock_Tree/STATUS_0: J1216.1; also elsewhere on the board
/Clock_Tree/STATUS_1: J1216.2; also elsewhere on the board
/DACs/DAC_MONITOR0: J1214.4; also elsewhere on the board
/DACs/DAC_MONITOR1: J1214.3; also elsewhere on the board
/DACs/DAC_MONITOR2: J1214.2; also elsewhere on the board
/DACs/DAC_MONITOR3: J1214.1; also elsewhere on the board
/DSP/CW_TONE: J1204.4; also elsewhere on the board
/DSP/DSP_AUX4: J1204.5; also elsewhere on the board
/DSP/DSP_AUX5: J1204.6; also elsewhere on the board
/DSP/DSP_AUX6: J1204.7; also elsewhere on the board
/DSP/DSP_AUX7: J1204.8; also elsewhere on the board
/DSP/VAD_ATT: J1204.1; also elsewhere on the board
/DSP/VAD_LPF: J1204.2; also elsewhere on the board
/DSP/VAD_REL: J1204.3; also elsewhere on the board
/DSP_MP06: J1207.1; also elsewhere on the board
/DSP_MP07: J1207.3; also elsewhere on the board
/DSP_MP10: J1207.5; also elsewhere on the board
/DSP_MP11: J1207.7; also elsewhere on the board
/DSP_MP12: J1207.9; also elsewhere on the board
/DSP_MP14: J1207.11; also elsewhere on the board
/DSP_MP15: J1207.13; also elsewhere on the board
/DSP_MP16: J1207.15; also elsewhere on the board
/DSP_MP17: J1207.17; also elsewhere on the board
/DSP_MP18: J1207.19; also elsewhere on the board
/DSP_MP19: J1207.21; also elsewhere on the board
/DSP_MP20: J1207.23; also elsewhere on the board
/DSP_MP21: D1202.2 (A); also elsewhere on the board
/DSP_MP22: D1201.2 (A); also elsewhere on the board
/DSP_MP23: D1205.2 (A); also elsewhere on the board
/DSP_MP24: D1204.2 (A); also elsewhere on the board
/DSP_MP25: D1203.2 (A); also elsewhere on the board
/DSP_RESET_b: J1218.6; also elsewhere on the board
/FDA_GAIN_SEL: J1219.37; also elsewhere on the board
/MIC_GAIN: J1219.31; also elsewhere on the board
/MODE_SEL: J1219.15; also elsewhere on the board
/NOTCH: J1219.29; also elsewhere on the board
/PHASE_SEL_8: J1218.11; also elsewhere on the board
/PUSH_TO_TALK: J1219.23; also elsewhere on the board
/RADIO_DIAL+: J1219.7; also elsewhere on the board
/RADIO_DIAL-: J1219.9; also elsewhere on the board
/RF_ATTENUATOR: J1219.33; also elsewhere on the board
/RIT: J1219.19; also elsewhere on the board
/RX_CLK_ADDR0: J1218.7; also elsewhere on the board
/RX_CLK_ADDR1: J1218.8; also elsewhere on the board
/SCL0: J1215.3, R105.2, R1217.2; also elsewhere on the board
/SCL1: J1215.7, R1222.2; also elsewhere on the board
/SDA0: J1215.5, R106.2, R1218.2; also elsewhere on the board
/SDA1: J1215.9, R1221.2; also elsewhere on the board
/SELECT+: J1219.1; also elsewhere on the board
/SELECT-: J1219.3; also elsewhere on the board
/SELECT_PB: J1219.5; also elsewhere on the board
/SPLIT: J1219.21; also elsewhere on the board
/SWIO_0: D1206.2 (A), J1218.1; also elsewhere on the board
/TDM3_BCLK_OUT_HEAD: J1212.2; also elsewhere on the board
/TDM3_LRCLK_IN_HEAD: J1213.2; also elsewhere on the board
/TDM3_LRCLK_OUT_HEAD: J1212.3; also elsewhere on the board
/TDM3_SDATA_IN_HEAD: J1213.3; also elsewhere on the board
/TDM3_SDATA_OUT_HEAD: J1212.4; also elsewhere on the board
/TDM3_SDOUT_IN_HEAD: J1213.4; also elsewhere on the board
/TX_CLK_ADDR0: J1218.9; also elsewhere on the board
/TX_CLK_ADDR1: J1218.10; also elsewhere on the board
/UART0_CTS: J1220.1; also elsewhere on the board
/UART0_RTS: J1220.3; also elsewhere on the board
/UART0_RX: J1220.5; also elsewhere on the board
/UART0_TX: J1220.7; also elsewhere on the board
/VOLUME: J1219.11; also elsewhere on the board
unnamed 283: AE1201.1 (A_1); also elsewhere on the board
unnamed 284: AE1202.1 (A_1); also elsewhere on the board
unnamed 310: R107.2; also elsewhere on the board
unnamed: D1201.1 (K), R1207.1
unnamed: D1202.1 (K), R1208.1
unnamed: D1203.1 (K), R1209.1
unnamed: D1204.1 (K), R1210.1
unnamed: D1205.1 (K), R1211.1
unnamed: D1206.1 (K), R1228.1
unnamed 418: L1101.2; also elsewhere on the board
