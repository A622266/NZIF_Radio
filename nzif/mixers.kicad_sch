File: nzif/mixers.kicad_sch (KiCad schematic)
At the start: 80 parts

Commit message: fixed file names
Parts:
- gave numbers to parts that had none: 78
